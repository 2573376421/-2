# Keil uVision project SEEKFREE.uvproj, settings and files
target STC8H8K64U (MCS-51)
  device: STC8G2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: SEEKFREE +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Libraries\libraries;..\..\Libraries\seekfree_libraries;..\..\Libraries\seekfree_peripheral;..\USER\inc;..\USER\src;..\CODE;..\..\Libraries\User_libraries
  link misc: REMOVEUNUSED
  group startup
    ../../Libraries/libraries/: common.c common.h board.c board.h STC8Hxx.h
  group seekfree_libraries
    ../../Libraries/seekfree_libraries/: zf_spi.c zf_spi.h zf_iic.c zf_iic.h zf_uart.c zf_uart.h zf_adc.c zf_adc.h zf_tim.c zf_exti.c zf_tim.h zf_pwm.c zf_pwm.h zf_exti.h zf_gpio.c zf_gpio.h zf_eeprom.c zf_eeprom.h zf_delay.c zf_delay.h zf_nvic.c zf_nvic.h zf_mdu16.c zf_mdu16.h
  group seekfree_peripheral
    ../../Libraries/seekfree_peripheral/: headfile.h SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_ABSOLUTE_ENCODER.c SEEKFREE_ABSOLUTE_ENCODER.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h
    ../../Libraries/libraries/: SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h
  group user_c
    ../USER/src/: isr.c main.c
    ../../Libraries/: version.txt
    ../../Libraries/User_libraries/: algorithm.c control.c motor.c
  group user_h
    ../USER/inc/: isr.h
    ../../Libraries/User_libraries/: algorithm.h control.h motor.h
